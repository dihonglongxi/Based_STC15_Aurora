# Keil uVision project Aurora.uvproj, settings and files
target BP-A1-CP_A (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: BP-A1-CP_A +hex
  c flags: Optimize=8 SizeSpeed=1
  group ProgSource
    ../ProgSource/: it.c adc.c main.c pca.c tim.c usart.c
  group ProgInc
    ../ProgInc/: adc.h config.h it.h pca.h STC15W408AS.H tim.h usart.h
