# Keil uVision project Aurora.uvproj, settings and files
target Aurora (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Aurora +hex
  c flags: Optimize=8 SizeSpeed=1
  group ProgSource
    ../ProgSource/: Aurora_Base_Config.c Aurora_Main.c Aurora_IT.c
  group ProgInc
    ../ProgInc/: STC15F2K60S2.H Aurora_Base_Config.h Aurora_IT.h
