# Keil uVision project Aurora_9x18.uvproj, settings and files
target Aurora_9x18 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Aurora_9x18 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Aurora_9x18
    ../ProgSource/: Aurora_9x18.c
    ../ProgInc/: STC15F2K60S2.H
